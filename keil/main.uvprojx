# Keil uVision project main.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_STM324xG_EVAL,
  c misc: --C99
  c include: ..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\my_file;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\keil;..\Utilities\STM32_EVAL\Common;..\Utilities\STM32_EVAL\STM3240_41_G_EVAL;..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group my_file
    ../my_file/: main.c stm32f4xx_it.c configuration.c global.c tftlcd.c tracking.c link_list.c camera.c parameter.c cmd.c cmd_func.c mpu6050.c interpreter.c
    ./: image.c utils.c
  group RVMDK
    ./: startup_stm32f40_41xxx.s
  group CMSIS
    ../my_file/: system_stm32f4xx.c
  group head
    ./: utils.h image.h
    ../my_file/: stm32f4xx_it.h configuration.h global.h tftlcd.h FONT.H tracking.h link_list.h parameter.h camera.h camera_cfg.h main.h cmd_func.h cmd.h mpu6050.h interpreter.h
  group StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
